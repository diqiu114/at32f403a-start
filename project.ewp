# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; AT32F403AVGT7; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\include; rt-thread\components\libc\compilers\common\extension\fcntl\octal; rt-thread\components\libc\posix\io\poll; libraries\AT32F403A_407_Firmware_Library\drivers\inc; libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\core_support; board\inc; rt-thread\libcpu\arm\common; rt-thread\libcpu\arm\cortex-m4; rt-thread\components\finsh; rt-thread\components\libc\compilers\common\include; .; applications; libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\device_support; rt-thread\components\drivers\include; board; rt-thread\components\libc\posix\io\stdio; rt-thread\components\libc\posix\ipc; rt-thread\components\libc\compilers\common\extension; libraries\rt_drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32f403a_407.s
    libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/AT32F403A_407_Firmware_Library/drivers/src/: at32f403a_407_exint.c at32f403a_407_emac.c at32f403a_407_rtc.c at32f403a_407_spi.c at32f403a_407_dac.c at32f403a_407_bpr.c at32f403a_407_gpio.c at32f403a_407_sdio.c at32f403a_407_wdt.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_dma.c at32f403a_407_pwc.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_crm.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_debug.c at32f403a_407_usb.c at32f403a_407_adc.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_xmc.c
    libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/: system_at32f403a_407.c
